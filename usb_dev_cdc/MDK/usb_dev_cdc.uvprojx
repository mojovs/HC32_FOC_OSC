# Keil uVision project usb_dev_cdc.uvprojx, settings and files
target usb_dev_cdc_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: usb_dev_cdc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,XTAL_VALUE=16000000,
  c include: ../source;../../../HC32F460_DDL_Rev3.3.0/drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../HC32F460_DDL_Rev3.3.0/drivers/cmsis/Include;../../../HC32F460_DDL_Rev3.3.0/drivers/hc32_ll_driver/inc;../../../HC32F460_DDL_Rev3.3.0/midwares/hc32/usb;../../../HC32F460_DDL_Rev3.3.0/midwares/hc32/usb/usb_device_lib/device_core;../../../HC32F460_DDL_Rev3.3.0/midwares/hc32/usb/usb_device_lib/device_class/single_cdc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f460.s
    ../../../HC32F460_DDL_Rev3.3.0/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group source
    ../source/: main.c cdc_data_process.c usb_bsp.c usb_dev_desc.c usb_dev_user.c
  group driver
    ../../../HC32F460_DDL_Rev3.3.0/drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_usb.c hc32_ll_utility.c
  group usb
    ../../../HC32F460_DDL_Rev3.3.0/midwares/hc32/usb/usb_device_lib/device_core/: usb_dev_core.c usb_dev_ctrleptrans.c usb_dev_driver.c usb_dev_int.c usb_dev_stdreq.c
    ../../../HC32F460_DDL_Rev3.3.0/midwares/hc32/usb/usb_device_lib/device_class/single_cdc/: usb_dev_cdc_class.c
  group Readme
    ../: Readme.txt
target usb_dev_cdc_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: as above
  output: usb_dev_cdc +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,XTAL_VALUE=16000000,
  c include: ../source;../../../HC32F460_DDL_Rev3.3.0/drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../HC32F460_DDL_Rev3.3.0/drivers/cmsis/Include;../../../HC32F460_DDL_Rev3.3.0/drivers/hc32_ll_driver/inc;../../../HC32F460_DDL_Rev3.3.0/midwares/hc32/usb;../../../HC32F460_DDL_Rev3.3.0/midwares/hc32/usb/usb_device_lib/device_core;../../../HC32F460_DDL_Rev3.3.0/midwares/hc32/usb/usb_device_lib/device_class/single_cdc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
